# Keil uVision project 90C52.uvproj, settings and files
target TFT_DEMO (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 90C52 +hex
  c flags: Optimize=8 SizeSpeed=1
  group C_code
    ./c/: main.c AT24C02.c DS1302.c gui.c IIC.c IR.c lcd_drive.c temp.c TIME.c touch.c UART.c
  group startup
    ./: STARTUP.A51
